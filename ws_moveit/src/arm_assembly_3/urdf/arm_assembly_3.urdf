Commit message: robot model updated, moveit config added

File: ws_moveit/src/arm_assembly_3/urdf/arm_assembly_3.urdf (robot description, URDF)
Before this commit: robot arm_assembly_3, 7 links, 6 joints
Links:
- link base_link: mass None -> 0.0319051544349151
